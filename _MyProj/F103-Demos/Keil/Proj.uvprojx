# Keil uVision project Proj.uvprojx, settings and files
target Proj (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Proj +hex
  AfterMake: .\Script\copyOUT.exe
  c flags: uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\Library\Peripheral\Inc;..\Library\System\Inc;..\Library\Drive\Inc;..\Library\Calc\Inc;..\Library\Core\Inc;-------------------------------------------------------------------------------;..\User\Main;..\User\Conf;..\Library\Peripheral\inc;-------------------------------------------------------------------------------;..\User\App\Inc;-------------------------------------------------------------------------------;..\User\OpenCode\letterShell;..\User\OpenCode\MultiButton;..\User\OpenCode\cm_backtrace;..\User\OpenCode\easylogger\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Library \ Peripheral
    ../Library/Peripheral/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_dbgmcu.c
  group Library \ System
    ../Library/System/Src/: gpio.c nvic.c systick.c tim.c usart.c system.c
  group Library \ Drive
    ../Library/Drive/Src/: key.c led.c debuguart.c breath.c oled.c
  group Library \ Calc
    ../Library/Calc/src/: fun.c sort.c
  group Library \ Core
    ../Library/Core/Src/: core_cm3.c
    ../Library/Core/Inc/: core_cm3.h
  group User \ App
    ../User/App/Src/: scheduler.c command.c
  group User \ Main
    ../User/Main/: main.c startup_stm32f10x_hd.s
  group User \ Conf
    ../User/Conf/: user_conf.c system_stm32f10x.c stm32f10x_conf.h stm32f10x_it.h
    ../User/Main/: stm32f10x.h
  group User \ Readme
    ../User/: Readme.md
  group OpenCode \ LetterShell
    ../User/OpenCode/letterShell/: shell.c README.md shell_ext.c
  group OpenCode \ MultiButton
    ../User/OpenCode/MultiButton/: multi_button.c README.md
  group OpenCode \ EasyLogger
    ../User/OpenCode/easylogger/port/: elog_port.c
    ../User/OpenCode/easylogger/src/: elog.c elog_utils.c
    ../User/OpenCode/easylogger/: README.md
  group OpenCode \ cm_backtrace
    ../User/OpenCode/cm_backtrace/fault_handler/keil/: cmb_fault.S
    ../User/OpenCode/cm_backtrace/: cm_backtrace.c README_ZH.md
