# Keil uVision project Proj.uvprojx, settings and files
target Proj (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Proj +hex
  AfterMake: .\Script\copyOUT.exe
  c flags: uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\Library\Peripheral\Inc;..\Library\System\Inc;..\Library\Drive\Inc;..\Library\Calc\Inc;..\Library\Core\Inc;-------------------------------------------------------------------------------;..\User\Main;..\User\Conf;..\Library\Peripheral\inc;-------------------------------------------------------------------------------;..\User\App\Inc;-------------------------------------------------------------------------------;..\User\OpenCode\letterShell;..\User\OpenCode\MultiButton;..\User\OpenCode\cm_backtrace;..\User\OpenCode\easylogger\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Library \ Peripheral
    ../Library/Peripheral/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_iwdg.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_sdio.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_pwr.c stm32f4xx_rng.c
  group Library \ System
    ../Library/System/Src/: exti.c gpio.c nvic.c systick.c tim.c usart.c xwdg.c system.c rtc.c rng.c
  group Library \ Drive
    ../Library/Drive/Src/: beep.c breath.c hc_sr04.c key.c lcd.c led.c touchkey.c debuguart.c rtcClock.c
  group Library \ Calc
    ../Library/Calc/src/: fun.c sort.c
  group Library \ Core
    ../Library/Core/Inc/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group User \ App
    ../User/App/Src/: scheduler.c command.c
  group User \ Main
    ../User/Main/: stm32f4xx.h main.c startup_stm32f40_41xxx.s
  group User \ Conf
    ../User/Conf/: stm32f4xx_conf.h user_handler.h user_handler.c system_stm32f4xx.h system_stm32f4xx.c user_conf.c
  group User \ Readme
    ../User/: Readme.md
  group OpenCode \ LetterShell
    ../User/OpenCode/letterShell/: shell.c README.md shell_ext.c
  group OpenCode \ MultiButton
    ../User/OpenCode/MultiButton/: multi_button.c README.md
  group OpenCode \ EasyLogger
    ../User/OpenCode/easylogger/port/: elog_port.c
    ../User/OpenCode/easylogger/src/: elog.c elog_utils.c
    ../User/OpenCode/easylogger/: README.md
  group OpenCode \ cm_backtrace
    ../User/OpenCode/cm_backtrace/fault_handler/keil/: cmb_fault.S
    ../User/OpenCode/cm_backtrace/: cm_backtrace.c README_ZH.md
