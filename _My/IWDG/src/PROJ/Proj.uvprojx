# Keil uVision project Proj.uvprojx, settings and files
target Proj (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: OUT +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\SET;..\CODE;..\FWLIB\inc;..\MAIN;..\PROJ;..\USERLIB;..\USERLIB\Inc;..\USERLIB\Inc_C
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CODE
    ../CODE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c
    ../../../USART - cpp/src/FWLIB/src/: stm32f4xx_iwdg.c
  group SETTING
    ../SET/: stm32f4xx_it.c system_stm32f4xx.c
  group MAIN
    ../MAIN/: main.cpp
  group CLIB
    ../USERLIB/Src_C/: usart.c sys.c
  group USERLIB
    ../USERLIB/Src/: Class_GPIO.cpp Class_Sys.cpp Class_USART.cpp Led..Beep..Key.cpp
  group README
    ./: 工程结构示意.txt
