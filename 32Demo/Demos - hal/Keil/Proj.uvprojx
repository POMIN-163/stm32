# Keil uVision project Proj.uvprojx, settings and files
target Proj (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Proj +hex
  AfterMake: .\Script\copyOUT.exe
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Library\Peripheral\inc;..\Library\Calc\inc;..\Library\Core;-------------------------------------------------------------------------------;..\User\Drive\System;..\User\Drive\Inc;..\User\Lib\Inc;..\User\Main
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Library \ Calc
    ../Library/Calc/src/: fun.c sort.c
  group Library \ Peripheral
    ../Library/Peripheral/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_exti.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c
  group User \ Lib
    ../User/Lib/Src/: system.c
  group User \ Main
    ../User/Main/: global.h main.c stm32f4xx_it.h stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Usre \ Drive
    ../User/Drive/Src/: led.c systick.c breath.c beep.c key.c
  group User \ Config
    ../User/Main/: assert.h stm32f4xx_hal_conf.h system_stm32f4xx.c startup_stm32f407xx.s
  group User \ Readme
    ../User/: Readme.txt
